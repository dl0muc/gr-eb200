options:
  parameters:
    author: DL1COM
    generate_options: qt_gui
    id: eb200_if_stream_udp_example
    output_language: python
    title: eb200_if_stream_udp_example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '640000'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: eb200_if_stream_decode_0
  id: eb200_if_stream_decode
  parameters:
    debug: 'False'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '32796'
    port: '60340'
    src_zeros: 'False'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'IF Stream ON: trac:udp:tag:on "172.20.40.61",60340,if'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 'IF Stream OFF: trac:udp:delete all'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [eb200_if_stream_decode_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [eb200_if_stream_decode_0, '0', qtgui_sink_x_0, '0']
- [network_udp_source_0, '0', eb200_if_stream_decode_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
