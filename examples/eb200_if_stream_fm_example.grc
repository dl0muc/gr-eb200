options:
  parameters:
    author: DL1COM
    category: Custom
    generate_options: qt_gui
    id: eb200_if_stream_fm_example
    output_language: python
    title: eb200_if_stream_fm_example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '640000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 4*48e3
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '5000.0'
    type: complex
  states: {}
- name: eb200_if_stream_decode_0
  id: eb200_if_stream_decode
  parameters:
    debug: 'False'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: '32796'
    port: '60340'
    src_zeros: 'False'
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '3'
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [eb200_if_stream_decode_0, '0', blocks_probe_rate_0, '0']
- [eb200_if_stream_decode_0, '0', qtgui_sink_x_0, '0']
- [eb200_if_stream_decode_0, '0', rational_resampler_xxx_0, '0']
- [network_udp_source_0, '0', eb200_if_stream_decode_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
